# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: NANO130KE3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.7
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\FreeRTOS\inc;.\inc;.\FreeRTOS\port\RVDS\ARM_CM0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ./src/: main.c utility.c fifo.c lcd.c rgb.c uart1.c
  group FreeRTOS_CORE
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
  group FreeRTOS_PORT
    ./FreeRTOS/port/MemMang/: heap_4.c
    ./FreeRTOS/port/RVDS/ARM_CM0/: port.c
  group inc
    ./inc/: FreeRTOSConfig.h
target FreeRTOS (5060020::V5.06 (build 20)::ARMCC)
  device: NANO130KE3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.7
  cpu: as above
  output: project
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 4.1.0, Device:Driver:CLK 3.01.000, Device:Driver:GPIO 3.01.000, Device:Driver:SYS 3.01.000, Device:Driver:Timer 3.01.000, Device:Driver:UART 3.01.000, Device:Startup 3.01.000
